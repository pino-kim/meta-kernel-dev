COMPATIBLE_MACHINE_append = "|qemuarm-kdev |qemuarm64-kdev |qemux86-kdev |qemux86-64-kdev"

